# Keil uVision project 12864.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: 12864hex +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Cfile;.\Hfile
  group Source Group 1
    ./: STARTUP.A51
    ./Cfile/: main.c 12864.c delay.c
